# Keil uVision project TinyCLR.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tinyclr.axf
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../../../../CLR/StartupLib/: CLRStartup.cpp
    ../../../../DeviceCode/Initialization/: tinyhal.cpp
    ../../../../DeviceCode/cores/arm/: fastcompile_tinyhal.cpp
    ../../../../DeviceCode/Targets/Native/STM32/DeviceCode/STM32_Bootstrap/: STM32_bootstrap.cpp
    ../../../../DeviceCode/Targets/Native/STM32/DeviceCode/STM32_IntC/: STM32_intc_functions.cpp
