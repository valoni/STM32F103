# Keil uVision project TinyCLR.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: tinyclr.axf
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../../../../CLR/StartupLib/: CLRStartup.cpp
    ../../../../DeviceCode/Initialization/: tinyhal.cpp
    ../../../../DeviceCode/cores/arm/: fastcompile_tinyhal.cpp
    ../../../../DeviceCode/Targets/Native/STM32/DeviceCode/STM32_Bootstrap/: STM32_bootstrap.cpp
    ../../../../DeviceCode/Targets/Native/STM32/DeviceCode/STM32_IntC/: STM32_intc_functions.cpp
